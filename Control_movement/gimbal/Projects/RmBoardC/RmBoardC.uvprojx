# Keil uVision project RmBoardC.uvprojx, settings and files
target RmBoardC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RmBoardC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__STDC_LIMIT_MACROS
  c misc: --cpp11
  c include: .\BoardConfig;.\Src;..\..\CMSIS;..\..\Lib\Include;..\..\Src;..\..\StdPeriphDriver\inc;..\..\Src\Controller;..\..\Src\Controller\Chassis;..\..\Src\Controller\Gimbal;..\..\Src\Controller\Shooter;..\..\Src\IMU;..\..\Src\IMU\AHRS;..\..\Src\IMU\MahonyAHRS;..\..\Src\CanMsg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriphDriver
    ../../StdPeriphDriver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group DspLib
    ../../Lib/: arm_cortexM4lf_math.lib
    ../../Src/IMU/AHRS/: AHRS.lib
  group BoardConfig
    ./BoardConfig/: stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ./Src/: bsp_rc.c bsp_buzzer.c bsp_can.c bsp_led.c bsp_host_com.c bsp_imu.c bsp_laser.c bsp_bmi088.c bsp_ist8310.c bsp_fric.c
  group Util
    ../../Src/: Math.cpp Pid.cpp Crc.cpp
    ../../Src/IMU/: PoseEstimator.cpp AHRSEstimator.cpp
    ../../Src/IMU/AHRS/: AHRS_middleware.c
    ../../Src/IMU/MahonyAHRS/: MahonyAHRS.c
  group Entity
    ../../Src/: Dr16.cpp CanManager.cpp CanMsgDispatcher.cpp DjiCanMotorCommander.cpp G6020.cpp G6020SensorHandler.cpp M2006.cpp M2006SensorHandler.cpp M3508.cpp M3508SensorHandler.cpp RobotEngine.cpp Entity.cpp Packet.cpp MemoryStream.cpp HostPacket.cpp BoardPacket.cpp Imu.cpp HostCom.cpp BMI088.cpp IST8310.cpp
  group Controller
    ../../Src/Controller/Chassis/: ChassisController.cpp ChassisStateTest.cpp ChassisStateKeyboardCtrl.cpp ChassisStateRotate.cpp ChassisHeadingState.cpp
    ../../Src/Controller/Shooter/: ShooterController.cpp
    ../../Src/Controller/Gimbal/: GimbalController.cpp GimbalStateRc.cpp GimbalStateMouseControl.cpp
  group CanMsg
    ../../Src/CanMsg/: ChassisCtrlMsg.cpp ChassisCtrlMsg2.cpp GimbalRefMsg.cpp
  group Main
    ./Src/: main.cpp
